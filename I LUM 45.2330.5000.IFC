Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: I LUM 45.2330.5000.IFC
Time: 2023-12-11T10:55:48
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: I LUM 45.2330.5000
In: Default Storey
SolidWorks Custom Properties - Description: I LUM 45.2330.5000
PSet_Mass_Property - Mass Measure: 7.11815; Area Measure: 0.52803 m2; Volume Measure: 0.00711815 m3
